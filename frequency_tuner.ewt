<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\adc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\eeprom.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\frequency_tuner.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\input_detection.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\input_detection.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pwm.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pwm.h</name>
  </file>
</project>


