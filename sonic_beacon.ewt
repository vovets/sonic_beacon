<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\delay.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\delay.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\eeprom.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\eeprom.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\frequency_detection.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\frequency_detection.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\hal.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\handlers.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\handlers.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\input.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\music.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\music.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pin_defs.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pwm.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\pwm.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\signal_detection.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\signal_detection.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\sonic_beacon.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\timeout_timer.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\timeout_timer.h</name>
  </file>
</project>


