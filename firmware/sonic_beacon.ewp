# IAR project sonic_beacon.ewp, settings and files
configuration Release (AVR)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x1e
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-1t-ec_nomul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: tiny85 ATtiny85
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnktiny85t.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=$EXE_DIR$\flash.hex; -Ointel-standard,(XDATA)=$EXE_DIR$\eeprom.hex; -Oraw-binary,(CODE)=$EXE_DIR$\flash.bin
configuration Debug (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgtiny85.xcl
  group (top)
    ./: delay.c delay.h eeprom.c eeprom.h frequency_detection.c frequency_detection.h hal.h handlers.c handlers.h input.h music.c music.h pin_defs.h pwm.c pwm.h signal_detection.c signal_detection.h sonic_beacon.c timeout_timer.c timeout_timer.h
